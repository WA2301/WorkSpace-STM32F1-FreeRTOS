# Keil uVision project Project.uvprojx, settings and files
target Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD
  c include: .\BSP;.\CMSIS\CoreSupport;.\CMSIS\DeviceSupport;.\StdPeriph_Driver\inc;.\FreeRTOS\App;.\FreeRTOS\Source\include;.\FreeRTOS\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ./BSP/: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS-APP
    ./FreeRTOS/App/: Task00_Alpha.c
  group FreeRTOS-Source
    ./FreeRTOS/Source/: heap_2.c list.c port.c tasks.c
  group CMSIS
    ./CMSIS/DeviceSupport/: system_stm32f10x.c
    ./CMSIS/CoreSupport/: core_cm3.c
  group Startup
    ./CMSIS/DeviceSupport/Startup/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
